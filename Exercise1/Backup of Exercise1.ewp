# IAR project Backup of Exercise1.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCIncludePath2: $PROJ_DIR$; ..\..\3rdParty\EvalBoards\Renesas\YRDKRX62N\BSP; ..\..\3rdParty\EvalBoards\Renesas\YRDKRX62N\BSP\uCOS-III; ..\..\3rdParty\uC-CPU; ..\..\3rdParty\uC-CPU\RX62N\IAR; ..\..\3rdParty\uC-LIB; ..\..\3rdParty\uCOS-III\Source; ..\..\3rdParty\uCOS-III\Ports\Renesas\RX600\IAR
  ICCRX.IccLang: 0
  OBJCOPY.OOCOutputFile: Exercise1.srec
  ILINK.IlinkOutputFile: a.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RX)
  as the first configuration, except:
  ICCRX.CCDefines: NDEBUG
  group (top)
    ./: exercise1.c led.c signextend.c
    ../../HandsOn/Exercise2/: led.h
