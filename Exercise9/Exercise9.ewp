# IAR project Exercise9.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F563NB R5F563NB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x0
  General.IStackSize: 0x200
  General.HeapSize: 0x800
  ICCRX.CCIncludePath2: $PROJ_DIR$; ..\..\3rdParty\Software\uC-CPU\RX\IAR; ..\..\3rdParty\Software\uC-CPU; ..\..\3rdParty\Examples\Renesas\YRDKRX63N\BSP\OS\uCOS-III; ..\..\3rdParty\Software\uCOS-III\Source; ..\..\3rdParty\Software\uCOS-III\Ports\Renesas\RX\IAR; ..\..\3rdParty\Examples\Renesas\YRDKRX63N\BSP\Glyph; ..\..\3rdParty\Software\uC-LIB; ..\..\3rdParty\Examples\Renesas\YRDKRX63N\BSP; ..\..\3rdParty\Examples\Renesas\YRDKRX63N\BSP\IAR
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  OBJCOPY.OOCOutputFile: Exercise9.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: adc.c adc.h adcisr.s alarm.c alarm.h bsp_cfg.h cpu_cfg.h depth.c depth.h display.c display.h exercise9.c heartbeat.c heartbeat.h interrupts.c lib_cfg.h orchestrator.c orchestrator.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h pushbutton.c pushbutton.h scuba.c scuba.h
  group BSP
    ../../3rdParty/Examples/Renesas/YRDKRX63N/BSP/: bsp.c bsp.h bsp_glcd.c bsp_glcd.h bsp_int.c bsp_int.h bsp_int_vect_tbl.h bsp_led.c bsp_led.h bsp_misc.c bsp_misc.h bsp_ser.c bsp_ser.h bsp_sys.c bsp_sys.h cpu_bsp.c os_bsp.c os_bsp.h
  group BSP/Glyph
    ../../3rdParty/Examples/Renesas/YRDKRX63N/BSP/Glyph/: font_8x8.c font_x5x7.c Glyph.c Glyph.h Glyph_cfg.h GlyphRegister.c ST7579_LCD.c ST7579_LCD.h types.h YRDKRX63N_RSPI0.c YRDKRX63N_RSPI0.h
  group BSP/IAR
    ../../3rdParty/Examples/Renesas/YRDKRX63N/BSP/IAR/: cstartup.s iodefine.h
  group BSP/OS/uC/OS-III
    ../../3rdParty/Examples/Renesas/YRDKRX63N/BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
  group uC/CPU
    ../../3rdParty/Software/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/CPU/Port/RX/IAR
    ../../3rdParty/Software/uC-CPU/RX/IAR/: cpu.h
  group uC/LIB
    ../../3rdParty/Software/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC/OS-III/Port/RX/IAR
    ../../3rdParty/Software/uCOS-III/Ports/Renesas/RX/IAR/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uC/OS-III/Source
    ../../3rdParty/Software/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
